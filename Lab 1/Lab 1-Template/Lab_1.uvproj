# Keil uVision project Lab_1.uvproj, settings and files
target Lab 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab_1
  c flags: Optim=1
  c include: C:\Keil\EE319Kware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: Lab 1.c startup.s
  group Libraries
    C:/Keil/EE319Kware/driverlib/rvmdk/: driverlib.lib
    C:/Keil/EE319Kware/driverlib/: uartstdio.c gpio.c interrupt.c sysctl.c uart.c
