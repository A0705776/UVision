# Keil uVision project Lab6.uvproj, settings and files
target Lab6 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab6
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;C:\Keil\EE319Kware\driverlib
  asm include: C:\Keil\EE319Kware\driverlib
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup.s Sound.c piano.c dac.c Lab6.c SysTick.c
  group Object code
    ./: texas.o
