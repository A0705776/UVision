# Keil uVision project Lab_1.uvproj, settings and files
target Lab 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab_1
  c flags: Optim=1
  c include: C:\Keil\EE319Kware
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: Lab 1.c startup.s
  group Libraries
    C:/Keil/EE319Kware/driverlib/rvmdk/: driverlib.lib
    C:/Keil/EE319Kware/driverlib/: gpio.c interrupt.c sysctl.c uart.c
    ./: uartstdio.c uartstdio.h
