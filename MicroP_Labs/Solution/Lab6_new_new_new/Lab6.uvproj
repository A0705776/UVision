# Keil uVision project Lab6.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab6
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;C:\Keil\EE319Kware\driverlib;C:\Keil\EE319Kware\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Lab6.c MCU_Clock.c MCU_Clock.h piano.c Piano.h Sound.c Sound.h startup.s SysTick.c SysTick.h tm4c123gh6pm.h dac.c dac.h
